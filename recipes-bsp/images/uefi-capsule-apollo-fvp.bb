#
# SPDX-License-Identifier: MIT
#

APOLLO_UEFI_CAPSULE_MACHINE = "apollo-fvp"

require uefi-capsule-apollo-common.inc
