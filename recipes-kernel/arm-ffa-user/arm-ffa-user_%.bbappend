require recipes-kernel/module-signing/apollo-external-module-signing.inc
